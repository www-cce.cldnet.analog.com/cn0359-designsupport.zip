# Allegro board CN0359 RevB Allegro File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1A: length 32.8
  BOTTOM w0.203: R34.1 41.26,40.9 40.69,40.33 40.69,24.59 38.48,22.38 32.09,22.38 31.48,21.78 31.48,18.18 31.76,17.9 U17.15
V1B: length 15.6
  BOTTOM w0.203: U17.2 40.81,17.9 41.19,18.28 41.19,29.95 41.69,30.46 R36.1
V2A: length 8.2
  BOTTOM w0.203: U17.7 41.06,14.65 42.14,15.73 R41.1
V2B: length 13.5
  BOTTOM w0.203: U17.10 34.61,14.65 35.09,14.18 35.09,10.48 36.09,9.48 R42.1
+VEXC: length 51.4
  TOP w0.203: v1(28.88,39.68) 21.99,39.68 v1(20.19,37.88)
  BOTTOM w0.203: R14.2 32.06,38.41 U9.1 ; R14.2 30.79,40.98 C45.2 ; R14.2 v1(28.88,39.68) 28.88,29.68 30.18,28.38 36.19,28.38 37.03,29.23 R24.1 ; U11.2 19.96,33.75 20.19,33.98 C54.1 v1(20.19,37.88) 20.19,38.58 19.48,39.28 15.49,39.28 14.52,38.32 14.52,35.45 D5.2
-VEXC: length 43.3
  TOP w0.203: v1(22.18,37.98) v1(29.48,37.98)
  BOTTOM w0.203: U9.7 32.71,31.93 R27.2 C68.2 29.69,29.78 29.48,29.98 v1(29.48,37.98) ; 22.18,37.98 v1(22.18,37.98) 22.18,37.98 ; 22.18,37.98 C67.1 22.18,36.78 22.18,33.31 22.39,33.1 U11.8 ; 22.18,37.98 22.18,39.38 21.08,40.48 14.38,40.48 12.65,38.74 12.65,35.45 D5.1
AD8253_A0: length 99.9
  TOP w0.203: v1(85.59,46.38) v1(82.09,46.38) 80.99,46.38 79.99,47.38 74.59,47.38 73.54,46.33 73.54,44.63 72.69,43.78 61.89,43.78 57.07,48.6 45,48.6 31.38,34.98 v1(25.38,34.98) ; v1(29.08,24.08) v1(29.08,18.38)
  BOTTOM w0.203: v1(29.08,24.08) 28.67,24.5 U15.4 28.67,28.3 28.44,28.53 28.44,34.13 27.58,34.98 v1(25.38,34.98) ; U7.40 84.46,45.25 v1(85.59,46.38) ; v1(29.08,18.38) 28.67,17.96 U18.4 ; U7.38 81.96,46.25 v1(82.09,46.38)
AD8253_A1: length 85.7
  TOP w0.203: v1(39.69,27.28) 39.69,31.38 37.98,33.08 37.98,40.18 45.59,47.78 56.08,47.78 61.09,42.78 72.09,42.78 75.59,39.28 v1(79.69,39.28) ; v1(30.08,17.78) v1(30.08,24.08)
  BOTTOM w0.203: v1(30.08,24.08) 29.17,25 U15.5 29.17,27.08 29.37,27.28 v1(39.69,27.28) ; v1(79.69,39.28) 79.01,39.95 U7.2 ; U18.5 29.17,17.46 29.48,17.78 v1(30.08,17.78)
AD8253_WR0: length 75.9
  TOP w0.203: v1(75.31,49.2) 68.31,49.2 64.89,45.78 61.59,45.78 57.79,49.58 43.48,49.58 v1(38.98,45.08)
  BOTTOM w0.203: U15.6 29.17,22.87 29.58,23.28 37.19,23.28 40.29,26.38 40.29,43.78 v1(38.98,45.08) ; U7.29 76.01,48.49 v1(75.31,49.2)
AD8253_WR1: length 90.7
  TOP w0.203: v1(81.89,41.48) 81.89,22.58 66.08,6.78 48.69,6.78 42.48,12.98 39.59,12.98 38.39,14.18 38.39,18.08 37.89,18.58 36.18,18.58 31.18,13.58 v1(29.17,13.58)
  BOTTOM w0.203: U7.46 81.11,42.25 v1(81.89,41.48) ; U18.6 v1(29.17,13.58)
ADC0: length 45.6
  BOTTOM w0.203: U7.8 76.01,39.51 73.98,37.48 C64.1 73.04,37.48 72.84,37.28 72.84,5.54 71.68,4.37 R53.2 66.16,4.27 R52.2
ADC1: length 30.5
  BOTTOM w0.203: U7.9 75.51,39.68 74.61,38.78 72.38,38.78 71.98,38.38 C72.1 71.29,37.48 70.98,37.18 70.98,21.78 69.5,20.3 R39.2 63.61,20.3 R38.2
ADC2: length 27.3
  BOTTOM w0.203: U7.10 75.01,39.8 74.49,39.28 70.58,39.28 70.09,38.78 C63.1 69.28,37.48 69.09,37.28 69.09,23.08 68.64,22.63 R32.2 64.76,22.63 R31.2
ADC3: length 13.6
  BOTTOM w0.203: U7.11 74.51,40.01 74.28,39.78 68.98,39.78 68.19,38.98 C52.1 65.41,37.48 R21.2 63.66,37.73 R20.2
DAC: length 43.3
  TOP w0.203: v1(36.78,41.28) 44.59,49.08 57.39,49.08 62.09,44.38 v1(72.28,44.38)
  BOTTOM w0.203: U7.19 72.41,44.25 v1(72.28,44.38) ; R16.1 v1(36.78,41.28)
FB1: length 14.1
  BOTTOM w0.203: C21.1 18.38,68.29 18.79,68.69 18.79,75.38 18.43,75.73 R3.1
  BOTTOM w1: E2.1 D1.C 15.8,68.29 C21.1
FB2: length 15.7
  BOTTOM w0.203: C23.1 10.47,68.29 9.79,68.98 9.79,77.68 10.04,77.93 R57.1
  BOTTOM w1: C23.1 D2.A E3.1
LCD_A0: length 20.7
  BOTTOM w0.203: U1.15 64.56,53.8 65.99,52.38 76.39,52.38 78.01,50.75 U7.33
LCD_BACKLIGHT_LED+: length 33.9
  BOTTOM w0.203: U1.A 44.31,64.5 R6.2 U6.2
LCD_BACKLIGHT_LED-: length 8.4
  BOTTOM w0.203: U1.K 72.86,63.3 72.16,64 U6.1
LCD_CSB: length 16.7
  TOP w0.203: v1(77.28,49.88) 74.98,52.18 v1(74.98,53.48)
  BOTTOM w0.203: v1(74.98,53.48) 68.89,53.48 67.57,54.79 67.56,54.8 67.56,54.82 U1.17 ; v1(77.28,49.88) 77.51,49.65 U7.32
LCD_MOSI: length 22.6
  TOP w0.203: v1(76.48,49.88) 73.98,52.38 v1(73.98,54.28)
  BOTTOM w0.203: v1(73.98,54.28) 70.28,57.98 63.04,57.98 U1.13 ; v1(76.48,49.88) 77.01,49.35 U7.31
LCD_RST: length 19.8
  BOTTOM w0.203: U1.16 66.06,53.9 67.08,52.88 76.59,52.88 78.51,50.95 U7.34
LCD_SCLK: length 19.5
  BOTTOM w0.203: U7.30 76.51,48.95 73.78,51.68 65.39,51.68 63.06,54 U1.14
PWM0: length 79.5
  TOP w0.203: v1(85.98,45.68) 80.99,45.68 79.79,46.88 74.69,46.88 73.98,46.18 73.98,44.29 72.97,43.28 61.48,43.28 56.57,48.19 45.3,48.19 31.51,34.41 v1(24.68,34.41)
  BOTTOM w0.203: U7.41 85.06,44.75 v1(85.98,45.68) ; U11.6 v1(24.68,34.41)
PWM1: length 101
  TOP w0.203: v1(36.29,17.88) 32.09,13.68 32.09,12.18 32.38,11.88 v1(36.09,11.88) 42.29,11.88 48.48,5.68 66.39,5.68 82.98,22.28 82.98,38.78 83.89,39.68 v1(83.89,42.88)
  BOTTOM w0.203: v1(36.09,11.88) 36.09,12.98 37.11,14 U17.8 ; v1(36.29,17.88) 34.59,17.88 33.91,18.55 U17.16 ; U7.42 82.51,44.25 v1(83.89,42.88)
PWM2: length 92.9
  TOP w0.203: v1(37.19,17.88) 32.77,13.46 v1(32.77,12.48) 42.29,12.48 48.59,6.18 66.06,6.18 82.48,22.61 82.48,40.88 v1(83.28,41.68)
  BOTTOM w0.203: U17.9 v1(32.77,12.48) ; U7.44 81.71,43.25 v1(83.28,41.68) ; U17.1 37.46,18.55 37.19,18.28 v1(37.19,17.88)
SWCLK: length 49.8
  BOTTOM w0.203: U7.47 80.71,41.75 82.09,40.38 89.69,40.38 92.78,37.28 92.78,27.58 97.28,23.08 106.98,23.08 107.89,22.18 107.89,17.48 107.32,16.91 R10.2 J4.4
SWDIO: length 47.2
  BOTTOM w0.203: U7.48 80.51,41.25 81.78,39.98 89.28,39.98 92.28,36.98 92.28,27.48 97.18,22.58 106.78,22.58 107.39,21.98 107.39,18.68 106.89,18.18 R54.2 J4.2
UNNAMED_2_AD8592_I160_: length 0.5
  BOTTOM w0.203: U6.8 U6.9
UNNAMED_2_AD8592_I160__1: length 7.3
  BOTTOM w0.203: C28.2 R8.2 R7.1 71.41,67.71 71.41,65.41 70.98,64.98 69.66,64.98 U6.3
UNNAMED_2_ADUCM36X_I1_AIN5: length 70.7
  BOTTOM w0.203: J3.3 C41.1 7.59,48.08 65.48,48.08 67.28,46.28 71.98,46.28 72.51,45.75 U7.22
UNNAMED_2_ADUCM36X_I1_AIN6: length 72.4
  BOTTOM w0.203: J3.2 C37.1 32.91,52.96 37.29,48.58 65.78,48.58 67.58,46.78 72.19,46.78 72.71,46.25 U7.23
UNNAMED_2_ADUCM36X_I1_AIN7: length 71
  BOTTOM w0.203: R13.1 8.93,56.53 C39.1 8.98,54.78 9.79,53.98 34.48,53.98 39.29,49.18 65.98,49.18 67.89,47.28 72.29,47.28 72.81,46.75 U7.24
UNNAMED_2_ADUCM36X_I1_AIN9: length 78.8
  TOP w0.203: v1(63.36,47.28) 63.29,47.35 v1(63.29,50.78)
  BOTTOM w0.203: v1(63.36,47.28) 43.88,47.28 42.79,46.18 26.29,46.18 22.9,42.8 C36.1 R12.1 R11.2 J3.4 ; v1(63.29,50.78) 73.09,50.78 74.51,49.35 U7.26
UNNAMED_2_ADUCM36X_I1_AVDDREG: length 19.6
  TOP w0.203: v1(67.69,42.08) 72.19,42.08 75.59,38.68 v1(75.98,38.68)
  BOTTOM w0.203: U7.18 73.28,43.78 C56.1 69.59,42.88 68.48,42.88 v1(67.69,42.08) ; U7.7 76.51,39.21 v1(75.98,38.68) 75.98,38.08 C44.1
UNNAMED_2_ADUCM36X_I1_INTREF: length 3
  BOTTOM w0.203: C42.1 72.18,45.28 72.7,44.75 U7.20
UNNAMED_2_ADUCM36X_I1_P0: length 32.3
  BOTTOM w0.203: J2.2 105.08,53.78 104.29,52.99 81.12,52.99 79.01,50.88 U7.35
UNNAMED_2_ADUCM36X_I1_P0_1: length 37.2
  BOTTOM w0.203: U7.36 79.51,50.61 81.48,52.58 105.48,52.58 106.78,53.88 106.78,57.34 106.21,57.91 J2.4
UNNAMED_2_ADUCM36X_I1_P1: length 36.5
  TOP w0.203: S1.A 88.96,19.91 86.89,21.98 v1(86.89,42.28)
  BOTTOM w0.203: v1(86.89,42.28) 86.89,46.38 86.28,46.98 85.19,46.98 83.96,45.76 80.22,45.76 U7.39
UNNAMED_2_ADUCM36X_I1_P1_1: length 29.9
  TOP w0.203: S1.B 83.96,20.25 85.89,22.18 85.89,40.08 v1(84.48,41.48)
  BOTTOM w0.203: U7.43 82.21,43.75 v1(84.48,41.48)
UNNAMED_2_ADUCM36X_I1_P1_2: length 49.6
  TOP w0.203: v1(88.59,41.68) 88.59,23.48 91.28,20.78 91.28,16.78 88.96,14.46 S1.1
  BOTTOM w0.203: U7.45 81.41,42.75 83.28,40.88 87.78,40.88 v1(88.59,41.68)
UNNAMED_2_ADUCM36X_I1_P2: length 20.3
  TOP w0.203: v1(91.45,40.44) 91.45,38.64 v1(89.78,36.98)
  BOTTOM w0.203: R17.2 R18.1 v1(91.45,40.44) ; U7.3 78.51,39.65 79.59,38.58 88.19,38.58 v1(89.78,36.98)
UNNAMED_2_ADUCM36X_I1_RESETN: length 63.9
  TOP w0.203: S2.2 v1(107.31,23.86)
  BOTTOM w0.203: v1(107.31,23.86) 108.91,22.26 108.91,13.41 107.38,11.88 100.48,11.88 96.89,15.48 96.89,22.28 91.78,27.38 91.78,36.78 89.09,39.48 80.32,39.48 79.51,40.28 U7.1
UNNAMED_2_CAP_I152_N1: length 2.4
  BOTTOM w0.203: U1.6 C34.1
UNNAMED_2_CAP_I152_N2: length 2.5
  BOTTOM w0.203: U1.7 52.56,54.18 C34.2
UNNAMED_2_CAP_I153_N1: length 2.4
  BOTTOM w0.203: U1.8 C33.1
UNNAMED_2_CAP_I153_N2: length 2.5
  BOTTOM w0.203: C33.2 55.56,54.18 U1.9
UNNAMED_2_CAP_I154_N1: length 2.4
  BOTTOM w0.203: U1.10 C32.1
UNNAMED_2_CAP_I156_N1: length 2.4
  BOTTOM w0.203: U1.1 C1.1
UNNAMED_2_CAP_I171_N1: length 2.4
  BOTTOM w0.203: U1.2 C51.1
UNNAMED_2_CAP_I172_N1: length 2.4
  BOTTOM w0.203: U1.3 C101.1
UNNAMED_2_CAP_I173_N1: length 2.4
  BOTTOM w0.203: U1.4 C105.1
UNNAMED_2_CAP_I174_N1: length 2.4
  BOTTOM w0.203: U1.5 C106.1
UNNAMED_2_CN4P_I8_N1: length 77.5
  BOTTOM w0.203: U7.25 74.01,47.98 73.81,48.18 67.69,48.18 66.08,49.78 39.98,49.78 29.65,60.11 9.81,60.11 8.98,59.28 C38.1 8.98,58.03 R13.2 7.38,58.04 J3.1
UNNAMED_2_CN10PODDEVEN_I92_N5: length 25.5
  TOP w0.203: J4.10 107.3,13.1 108.71,14.51 108.71,32.11 107.86,32.96 S2.1
UNNAMED_2_CN10PODDEVEN_I95_N1: length 1.5
  BOTTOM w0.203: J4.1 R9.2
UNNAMED_2_DIO_I30_N: length 5
  BOTTOM w0.203: Q1.3 D4.C U2.P
UNNAMED_2_RES_I133_N2: length 1.9
  BOTTOM w0.203: R18.2 93.95,40.42 Q1.1
UNNAMED_3_ADA40772_I167_: length 4.8
  BOTTOM w0.203: U9.2 32.71,39.26 R14.1 C45.1 R15.2
UNNAMED_3_ADA40772_I167__1: length 3.6
  BOTTOM w0.203: R16.2 C49.1 33.36,39.28 U9.3
UNNAMED_3_ADA40772_I180_: length 5.3
  BOTTOM w0.203: R27.1 33.86,29.88 C68.1 ; R27.1 33.36,31.88 U9.6 ; R27.1 35.21,31.38 R24.2
UNNAMED_3_ADA40772_I180__1: length 3.2
  BOTTOM w0.203: R22.2 C59.1 U9.5
UNNAMED_3_ADP2301_I1_BST: length 2.1
  BOTTOM w0.203: C17.2 31.36,90.28 30.34,89.27 U4.1
UNNAMED_3_ADP2301_I1_FB: length 14
  BOTTOM w0.203: U4.3 27.81,85.86 29.08,84.58 R2.1 R5.2
UNNAMED_3_ADP5072_I216_AVIN: length 47.1
  TOP w0.8: v1(13.09,76.18) v1(15.99,76.18) 25.29,76.18 30.68,81.58 v1(37.98,81.58)
  BOTTOM w0.203: U5.C4 15.34,76.82 v1(15.99,76.18) 16.71,75.46 L1.2 ; U5.C2 U5.C1 U5.B1 U5.A1 13.4,76.02 13.24,76.18 v1(13.09,76.18) 11.99,75.08 C12.1 ; U5.C2 U5.D2 ; U5.C2 U5.B2
  BOTTOM w0.8: C31.1 38.09,81.68 v1(37.98,81.58)
  BOTTOM w1: C26.1 C31.1 E1.1 ; C26.1 C25.1 39.36,85.01 L2.2 ; C26.1 R5.1
UNNAMED_3_ADP5072_I216_COMP1: length 2.6
  BOTTOM w0.203: R1.1 16.09,78.87 U5.E4
UNNAMED_3_ADP5072_I216_COMP2: length 2.6
  BOTTOM w0.203: R59.1 12.69,79.53 12.69,78.58 U5.E1
UNNAMED_3_ADP5072_I216_FB1: length 4
  BOTTOM w0.203: R4.1 R3.2 17.48,77.22 U5.D4
UNNAMED_3_ADP5072_I216_FB2: length 5.1
  TOP w0.203: v1(12.09,78.93) v1(13.49,78.93)
  BOTTOM w0.203: U5.E2 14.04,78.38 v1(13.49,78.93) 13.49,78.93 R58.1 ; v1(12.09,78.93) 11.69,78.93 R57.2
UNNAMED_3_ADP5072_I216_SW2: length 6.3
  BOTTOM w0.203: U5.A2 14.04,75.14 13.76,74.86
  BOTTOM w0.5: L3.2 13.41,74.51 13.76,74.86
  BOTTOM w1: L3.2 13.41,70.15 D2.C
UNNAMED_3_ADP5072_I216_SW11: length 6.3
  BOTTOM w0.203: 14.76,74.86 14.44,75.18 U5.A3 U5.B3
  BOTTOM w0.5: 14.76,74.86 15.26,74.36 L1.1
  BOTTOM w1: D1.A 15.26,70.57 L1.1
UNNAMED_3_ADP5072_I216_VREF: length 4.2
  BOTTOM w0.203: U5.E3 14.44,78.43 14.99,78.98 R58.2 14.99,80.98 C13.1
UNNAMED_3_CAP_I106_N1: length 4.4
  BOTTOM w0.4: 14.24,87.61 J1.1 ; J1.1 14.24,90.54 ; J1.1 12.78,89.08
UNNAMED_3_CAP_I220_N1: length 1.2
  BOTTOM w0.203: R1.2 C24.1
UNNAMED_3_CAP_I221_N1: length 1.2
  BOTTOM w0.203: C16.1 R59.2
UNNAMED_4_AD8253_I20_OUT: length 1.9
  BOTTOM w0.203: U18.7 R45.1
UNNAMED_4_AD8253_I20_REF: length 9.6
  BOTTOM w0.203: U22.2 U22.1 30.32,7.39 30.03,7.68 C92.1 30.03,9.16 29.91,9.28 27.98,9.28 27.67,9.6 U18.9
UNNAMED_4_AD8253_I171_INNEG: length 22.3
  TOP w0.203: C103.2 v1(11.69,26.29)
  BOTTOM w0.203: v1(11.69,26.29) 11.69,26.85 12.15,27.31 13.41,27.31 13.61,27.51 JP4.2 ; v1(11.69,26.29) 12.49,26.29 12.91,26.71 20.31,26.71 20.73,26.29 U15.1 ; v1(11.69,26.29) JP2.2
UNNAMED_4_AD8253_I171_INPOS: length 15.6
  TOP w0.203: v1(19.86,22.46) 19.86,20.26 20.51,19.61 25.91,19.61 v1(27.11,20.81)
  BOTTOM w0.203: U14.1 19.86,23.15 v1(19.86,22.46) 20.28,22.04 R35.2 20.23,20.53 C78.2 ; v1(27.11,20.81) 27.17,20.87 U15.10
UNNAMED_4_AD8253_I171_OUT: length 1.8
  BOTTOM w0.203: U15.7 R33.1
UNNAMED_4_AD8253_I171_REF: length 23.1
  TOP w0.203: v1(25.58,11.98) 25.58,8.38 v1(24.18,6.98)
  BOTTOM w0.203: C79.1 25.22,19.98 26.18,19.98 ; 26.18,19.98 26.18,12.58 v1(25.58,11.98) ; 26.18,19.98 27.38,19.98 27.67,20.26 U15.9 ; v1(24.18,6.98) 23.61,6.41 23.61,5.19 23.92,4.88 U22.7 U22.6
UNNAMED_4_ADA46X7_I119_: length 25.6
  BOTTOM w0.203: C95.1 20.23,7.03 R47.1 20.28,9.89 20.06,10.1 U19.2 9.46,10.1 8.29,11.28 8.29,14.98 7.14,16.13 J5.4
UNNAMED_4_ADA46X7_I119__1: length 3.6
  BOTTOM w0.203: U19.3 C83.1 R40.2
UNNAMED_4_ADA46X7_I119_OUT: length 11.6
  BOTTOM w0.203: U18.10 27.17,11.66 26.79,11.28 23.66,11.28 U19.6 22.18,11.37 21.78,10.97 R47.2 21.83,7.03 C95.2
UNNAMED_4_ADA46221V2_I6_: length 7.1
  BOTTOM w0.203: U14.4 22.2,25.05 22.2,24.21 21.99,24.01 21.31,24.01 21.01,23.71 21.01,22.31 21.78,21.54 R35.1 21.83,20.53 C78.1
UNNAMED_4_ADG1419_I1_D: length 1.5
  BOTTOM w0.203: R23.2 U11.1
UNNAMED_4_ADG1611_I193_S1: length 10.6
  BOTTOM w0.203: U17.3 U17.14 31.55,17.25 31.5,17.31 31.36,17.31 30.17,18.5 R33.2
UNNAMED_4_ADG1611_I193_S3: length 12.5
  BOTTOM w0.203: U17.6 U17.11 32.75,15.28 31.58,15.28 30.17,13.86 R45.2
UNNAMED_4_CAP_I166_N1: length 6.8
  TOP w0.203: C103.1 v1(8.09,26.29)
  BOTTOM w0.203: J5.2 v1(8.09,26.29) JP2.1
UNNAMED_4_CAP_I167_N1: length 6.8
  TOP w0.203: C104.1 v1(8.11,21.21)
  BOTTOM w0.203: J5.3 v1(8.11,21.21) JP3.1
UNNAMED_4_CAP_I167_N2: length 13.5
  TOP w0.203: v1(11.76,21.21) C104.2
  BOTTOM w0.203: U14.3 14.43,25.07 13.61,24.25 JP5.1 13.61,22.11 12.71,21.21 v1(11.76,21.21) JP3.2
UNNAMED_4_CAP_I168_N1: length 8.3
  TOP w0.203: C102.1 v1(11.87,31.37)
  BOTTOM w0.203: R23.1 15.88,33.16 13.62,33.16 D5.3 13.59,31.78 13.17,31.37 v1(11.87,31.37) JP1.2
UNNAMED_4_CAP_I168_N2: length 6.7
  TOP w0.203: C102.2 v1(8.2,31.37)
  BOTTOM w0.203: JP1.1 v1(8.2,31.37) J5.1
UNNAMED_4_NC2P_I230_N1: length 2.1
  BOTTOM w0.203: JP4.1 R55.1
UNNAMED_4_NC2P_I231_N2: length 2.1
  BOTTOM w0.203: JP5.2 R56.2
UNNAMED_5_ADA45282_I8_: length 16.2
  BOTTOM w0.203: C75.1 R31.1 ; C75.1 U12.2 ; C75.1 57.98,25.88 57.69,26.18 57.69,30.18 57.41,30.46 R29.2
UNNAMED_5_ADA45282_I8__1: length 5.4
  BOTTOM w0.203: C74.1 R28.2 63.29,29.78 64.01,29.06 U12.3
UNNAMED_5_ADA45282_I8_OUT: length 4.1
  BOTTOM w0.203: U12.1 65.31,26.83 C75.2 R32.1
UNNAMED_5_ADA45282_I25_: length 4.5
  BOTTOM w0.203: C62.1 R26.2 63.09,30.98 63.36,31.25 U12.5
UNNAMED_5_ADA45282_I25__1: length 16.2
  BOTTOM w0.203: R20.1 C55.1 ; C55.1 60.59,34.48 58.69,36.38 58.69,40.38 58.16,40.9 R19.2 ; C55.1 64.01,34.03 U12.6
UNNAMED_5_ADA45282_I25_OUT: length 4
  BOTTOM w0.203: R21.1 C55.2 64.66,33.98 U12.7
UNNAMED_5_ADA45282_I43_: length 4.4
  BOTTOM w0.203: U20.5 63.39,14.6 63.39,13.58 63.09,13.28 R44.2 C89.1
UNNAMED_5_ADA45282_I43__1: length 12.1
  BOTTOM w0.203: U20.6 64.01,15.77 63.53,16.25 C85.1 63.53,18.67 R38.1 63.42,18.78 61.98,18.78 60.8,19.97 R37.2
UNNAMED_5_ADA45282_I43_OUT: length 4.4
  BOTTOM w0.203: R39.1 65.16,17.07 C85.2 65.13,16.25 64.66,15.77 U20.7
UNNAMED_5_ADA45282_I56_: length 13.2
  BOTTOM w0.203: R48.2 59.09,9.48 60.89,7.68 C96.1 ; C96.1 U20.2 ; C96.1 R52.1
UNNAMED_5_ADA45282_I56__1: length 5.7
  BOTTOM w0.203: C94.1 R46.2 63.59,12.08 63.98,11.68 63.98,10.05 U20.3
UNNAMED_5_ADA45282_I56_OUT: length 4.6
  BOTTOM w0.203: R53.1 C96.2 66.26,8.51 65.31,9.46 U20.1
UNNAMED_5_ADOPAMP1V4_I4_INV: length 5.9
  BOTTOM w0.203: C76.1 49.22,24.98 R30.1 49.22,28.84 48.88,29.19 U13.2
UNNAMED_5_ADOPAMP1V4_I4_NINV: length 3.8
  BOTTOM w0.203: U13.3 C73.1 R36.2
UNNAMED_5_ADOPAMP1V4_I4_OUT: length 9.3
  BOTTOM w0.203: R29.1 U13.6 51.26,30.46 50.72,29.92 R30.2 C76.2
UNNAMED_5_ADOPAMP1V4_I21_INV: length 5.9
  BOTTOM w0.203: U10.2 48.79,39.68 49.17,39.29 R25.1 C60.1
UNNAMED_5_ADOPAMP1V4_I21_NINV: length 3.8
  BOTTOM w0.203: R34.2 43.68,40.95 C50.1 U10.3
UNNAMED_5_ADOPAMP1V4_I21_OUT: length 9.6
  BOTTOM w0.203: C60.2 50.77,36.58 R25.2 50.67,40.67 50.95,40.95 U10.6 54.69,40.95 R19.1
UNNAMED_5_ADOPAMP1V4_I49_INV: length 6
  BOTTOM w0.203: C87.1 49.22,14.38 R43.1 49.22,18.34 48.89,18.68 47.45,18.68 U16.2
UNNAMED_5_ADOPAMP1V4_I49_NINV: length 3.8
  BOTTOM w0.203: U16.3 C84.1 43.67,19.97 R41.2
UNNAMED_5_ADOPAMP1V4_I49_OUT: length 9.5
  BOTTOM w0.203: R37.1 U16.6 51.07,19.97 50.72,19.62 R43.2 C87.2
UNNAMED_5_ADOPAMP1V4_I61_INV: length 6.2
  BOTTOM w0.203: C97.1 R51.1 49.22,7.79 48.8,8.21 U21.2
UNNAMED_5_ADOPAMP1V4_I61_NINV: length 4
  BOTTOM w0.203: R42.2 C93.1 U21.3
UNNAMED_5_ADOPAMP1V4_I61_OUT: length 9.7
  BOTTOM w0.203: R48.1 U21.6 52.51,9.48 51.12,9.48 50.72,9.09 R51.2 50.72,3.7 C97.2
VMID: length 67.7
  TOP w0.203: v1(58.98,29.78) v1(58.98,13.28) v1(58.98,7.88)
  BOTTOM w0.203: v1(58.98,29.78) R28.1 R26.1 ; R50.1 38.24,3.92 39.98,2.18 57.59,2.18 58.98,3.58 v1(58.98,7.88) ; R50.1 R49.2 ; R50.1 C100.1 C99.1 31.85,3.92 31.54,3.61 U22.3 27.01,3.61 25.74,2.34 U22.5 ; v1(58.98,13.28) R44.1 R46.1
XTALI: length 6.9
  BOTTOM w0.203: U7.5 77.51,38.95 78.48,37.98 C65.1 79.54,35.53 Y1.2
XTALO: length 10.9
  BOTTOM w0.203: Y1.1 82.03,35.43 C66.1 83.19,37.64 82.75,38.08 79.06,38.08 78.01,39.13 U7.4

## Copper pours and planes (outline as drawn)
+3.3V on BOTTOM: 69.09,65.68 69.09,69.91 67.08,69.91 67.08,65.68
GND on TOP: 1,101.87 110.12,101.87 110.12,1 1,1 ; 4 cut-outs
GND on BOTTOM: 1,101.87 110.12,101.87 110.12,1 1,1 ; 19 cut-outs
VCC on BOTTOM: 18.59,93.48 18.59,91.28 29.18,91.28 29.18,93.48
UNNAMED_3_ADP2301_I1_SW on BOTTOM: 29.38,93.48 29.38,91.28 40.69,91.28 40.69,93.48
UNNAMED_3_CAP_I106_N1 on BOTTOM: 13.59,93.68 17.48,93.68 17.48,92.48 15.88,92.48 15.88,86.98 13.19,86.98 12.29,87.88 12.29,89.68 13.59,90.98

## Text on the board
Ref Des/Silkscreen Bottom: C | A
User.Comments: SEE NOTE 5 | 5.    ADD CONTROL KNOB (N059034) TO THE SHAFT OF S1.
Ref Des/Assembly Top: 1
Ref Des/Silkscreen Top: 1 | EVAL-CN0359-EBZ
PAGE_OUTLINE: 21JUL21 | B | C | AS PER ECR-109977 | AS PER ECR-111700 | 15SEP22 | 24NOV22 | A.UY | CUSTOMER EVAL Z
DIMENSION: (REF) | - | " " | DIAMAX
User.11: WIRE ENTRY
User.12: ASSEMBLY NOTES: | 1.    SOLDER SHORT JP1, JP2 & JP3.
User.24: C | A
User.45: FIGURE | SIZE | 0.254 | 0.7112 | 0.889 | 1.016 | 1.143 | 1.27 | 1.651 | 1.905 | 1.0414 | 3.175 | 2.667x2.159 | DRILL CHART: TOP to BOTTOM | FINISHED HOLES IN MILLIMETERS | PLATED | NON-PLATED | QTY | 488 | 10 | 19 | 5 | 9 | 2 | 3 | 4 | TOLERANCE/NOTES
